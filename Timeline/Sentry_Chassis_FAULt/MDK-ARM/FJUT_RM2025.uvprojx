# Keil uVision project FJUT_RM2025.uvprojx, settings and files
target FJUT_RM2025 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Templates
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\LIB\BSP\inc;..\LIB\APP\inc;..\LIB\HARDWARE\inc;..\LIB\TCA\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c
    ../LIB/BSP/src/: it.c
  group CORE
    ../USER/: stm32f4xx_it.c system_stm32f4xx.c FreeRTOSConfig.h
    ../CORE/: startup_stm32f427x.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_iwdg.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group BSP
    ../LIB/BSP/src/: can.c dma.c io.c it.c nvic.c tim.c uart.c
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
