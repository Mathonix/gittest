# Keil uVision project FJUT_RM2025.uvprojx, settings and files
target FJUT_RM2025 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F427II STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Templates
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F427X,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__TARGET_FPU_VFP
  c include: ..\CORE;..\FWLIB\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\LIB\APP\inc;..\LIB\BSP\inc;..\LIB\HARDWARE\inc;..\LIB\TCA\inc;..\LIB\Judge\inc;..\LIB\DSP\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c FreeRTOSConfig.h
    ../user/: it.c
  group BSP
    ../LIB/BSP/src/: io.c can.c dma.c nvic.c tim.c uart.c
  group HARDWARE
    ../LIB/HARDWARE/src/: motor.c rm_remote.c hi219m.c imu_data_decode.c packet.c vofa.c
  group APP
    ../LIB/APP/src/: chassis_behavior.c minipc.c offline_detection.c user_task.c
  group TCA
    ../LIB/TCA/src/: kalman.c pid.c crc_check.c signal.c KalmanFliter.c
  group Judge
    ../LIB/Judge/src/: Arraylist.c judge.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c
  group CORE
    ../USER/: stm32f4xx_it.c system_stm32f4xx.c
    ../CORE/: startup_stm32f427x.s
  group FreeRTOS_CORE
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/MemMang/: heap_4.c
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
  group DSP
    ../LIB/DSP/src/: arm_cortexM4lf_math.lib
